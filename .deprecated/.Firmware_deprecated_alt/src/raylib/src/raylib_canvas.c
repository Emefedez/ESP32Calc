#include "raylib_canvas.h"
#include <string.h>
#include <math.h>

// RGB565 framebuffer
static uint16_t fb[RL_CANVAS_WIDTH * RL_CANVAS_HEIGHT];

// Simple 5x7 font
static const uint8_t font5x7[][5] = {
    {0x00,0x00,0x00,0x00,0x00}, {0x00,0x00,0x4f,0x00,0x00}, {0x00,0x07,0x00,0x07,0x00},
    {0x14,0x7f,0x14,0x7f,0x14}, {0x24,0x2a,0x7f,0x2a,0x12}, {0x23,0x13,0x08,0x64,0x62},
    {0x36,0x49,0x55,0x22,0x50}, {0x00,0x05,0x03,0x00,0x00}, {0x00,0x1c,0x22,0x41,0x00},
    {0x00,0x41,0x22,0x1c,0x00}, {0x08,0x2a,0x1c,0x2a,0x08}, {0x08,0x08,0x3e,0x08,0x08},
    {0x00,0x50,0x30,0x00,0x00}, {0x08,0x08,0x08,0x08,0x08}, {0x00,0x60,0x60,0x00,0x00},
    {0x20,0x10,0x08,0x04,0x02}, {0x3e,0x51,0x49,0x45,0x3e}, {0x00,0x42,0x7f,0x40,0x00},
    {0x42,0x61,0x51,0x49,0x46}, {0x21,0x41,0x45,0x4b,0x31}, {0x18,0x14,0x12,0x7f,0x10},
    {0x27,0x45,0x45,0x45,0x39}, {0x3c,0x4a,0x49,0x49,0x30}, {0x01,0x71,0x09,0x05,0x03},
    {0x36,0x49,0x49,0x49,0x36}, {0x06,0x49,0x49,0x29,0x1e}, {0x00,0x36,0x36,0x00,0x00},
    {0x00,0x56,0x36,0x00,0x00}, {0x00,0x08,0x14,0x22,0x41}, {0x14,0x14,0x14,0x14,0x14},
    {0x41,0x22,0x14,0x08,0x00}, {0x02,0x01,0x51,0x09,0x06}, {0x32,0x49,0x79,0x41,0x3e},
    {0x7e,0x11,0x11,0x11,0x7e}, {0x7f,0x49,0x49,0x49,0x36}, {0x3e,0x41,0x41,0x41,0x22},
    {0x7f,0x41,0x41,0x22,0x1c}, {0x7f,0x49,0x49,0x49,0x41}, {0x7f,0x09,0x09,0x01,0x01},
    {0x3e,0x41,0x41,0x51,0x32}, {0x7f,0x08,0x08,0x08,0x7f}, {0x00,0x41,0x7f,0x41,0x00},
    {0x20,0x40,0x41,0x3f,0x01}, {0x7f,0x08,0x14,0x22,0x41}, {0x7f,0x40,0x40,0x40,0x40},
    {0x7f,0x02,0x04,0x02,0x7f}, {0x7f,0x04,0x08,0x10,0x7f}, {0x3e,0x41,0x41,0x41,0x3e},
    {0x7f,0x09,0x09,0x09,0x06}, {0x3e,0x41,0x51,0x21,0x5e}, {0x7f,0x09,0x19,0x29,0x46},
    {0x46,0x49,0x49,0x49,0x31}, {0x01,0x01,0x7f,0x01,0x01}, {0x3f,0x40,0x40,0x40,0x3f},
    {0x1f,0x20,0x40,0x20,0x1f}, {0x7f,0x20,0x18,0x20,0x7f}, {0x63,0x14,0x08,0x14,0x63},
    {0x03,0x04,0x78,0x04,0x03}, {0x61,0x51,0x49,0x45,0x43}, {0x00,0x00,0x7f,0x41,0x41},
    {0x02,0x04,0x08,0x10,0x20}, {0x41,0x41,0x7f,0x00,0x00}, {0x04,0x02,0x01,0x02,0x04},
    {0x40,0x40,0x40,0x40,0x40}, {0x00,0x01,0x02,0x04,0x00}, {0x20,0x54,0x54,0x54,0x78},
    {0x7f,0x48,0x44,0x44,0x38}, {0x38,0x44,0x44,0x44,0x20}, {0x38,0x44,0x44,0x48,0x7f},
    {0x38,0x54,0x54,0x54,0x18}, {0x08,0x7e,0x09,0x01,0x02}, {0x08,0x14,0x54,0x54,0x3c},
    {0x7f,0x08,0x04,0x04,0x78}, {0x00,0x44,0x7d,0x40,0x00}, {0x20,0x40,0x44,0x3d,0x00},
    {0x00,0x7f,0x10,0x28,0x44}, {0x00,0x41,0x7f,0x40,0x00}, {0x7c,0x04,0x18,0x04,0x78},
    {0x7c,0x08,0x04,0x04,0x78}, {0x38,0x44,0x44,0x44,0x38}, {0x7c,0x14,0x14,0x14,0x08},
    {0x08,0x14,0x14,0x18,0x7c}, {0x7c,0x08,0x04,0x04,0x08}, {0x48,0x54,0x54,0x54,0x20},
    {0x04,0x3f,0x44,0x40,0x20}, {0x3c,0x40,0x40,0x20,0x7c}, {0x1c,0x20,0x40,0x20,0x1c},
    {0x3c,0x40,0x30,0x40,0x3c}, {0x44,0x28,0x10,0x28,0x44}, {0x0c,0x50,0x50,0x50,0x3c},
    {0x44,0x64,0x54,0x4c,0x44}, {0x00,0x08,0x36,0x41,0x00}, {0x00,0x00,0x7f,0x00,0x00},
    {0x00,0x41,0x36,0x08,0x00}, {0x08,0x04,0x08,0x10,0x08}, {0x00,0x00,0x00,0x00,0x00}
};

static uint16_t color_to_rgb565(Color c) {
    return ((c.r >> 3) << 11) | ((c.g >> 2) << 5) | (c.b >> 3);
}

void rl_init(void) {
    memset(fb, 0xFF, sizeof(fb));  // White
}

void rl_begin_drawing(void) {
    // No-op for now
}

void rl_end_drawing(void) {
    // No-op - framebuffer is ready
}

void rl_clear_background(Color color) {
    uint16_t c = color_to_rgb565(color);
    for (int i = 0; i < RL_CANVAS_WIDTH * RL_CANVAS_HEIGHT; i++) {
        fb[i] = c;
    }
}

void rl_draw_pixel(int x, int y, Color color) {
    if (x < 0 || x >= RL_CANVAS_WIDTH || y < 0 || y >= RL_CANVAS_HEIGHT) return;
    fb[y * RL_CANVAS_WIDTH + x] = color_to_rgb565(color);
}

void rl_draw_line(int x1, int y1, int x2, int y2, Color color) {
    int dx = abs(x2 - x1);
    int sx = x1 < x2 ? 1 : -1;
    int dy = -abs(y2 - y1);
    int sy = y1 < y2 ? 1 : -1;
    int err = dx + dy;
    while (1) {
        rl_draw_pixel(x1, y1, color);
        if (x1 == x2 && y1 == y2) break;
        int e2 = 2 * err;
        if (e2 >= dy) { err += dy; x1 += sx; }
        if (e2 <= dx) { err += dx; y1 += sy; }
    }
}

void rl_draw_rectangle(int x, int y, int w, int h, Color color) {
    uint16_t c = color_to_rgb565(color);
    for (int j = y; j < y + h && j < RL_CANVAS_HEIGHT; j++) {
        for (int i = x; i < x + w && i < RL_CANVAS_WIDTH; i++) {
            if (i >= 0 && j >= 0) fb[j * RL_CANVAS_WIDTH + i] = c;
        }
    }
}

void rl_draw_rectangle_lines(int x, int y, int w, int h, Color color) {
    rl_draw_rectangle(x, y, w, 1, color);
    rl_draw_rectangle(x, y + h - 1, w, 1, color);
    rl_draw_rectangle(x, y, 1, h, color);
    rl_draw_rectangle(x + w - 1, y, 1, h, color);
}

void rl_draw_circle(int x, int y, int radius, Color color) {
    for (int cy = -radius; cy <= radius; cy++) {
        for (int cx = -radius; cx <= radius; cx++) {
            if (cx * cx + cy * cy <= radius * radius) {
                rl_draw_pixel(x + cx, y + cy, color);
            }
        }
    }
}

void rl_draw_text(const char *text, int x, int y, int size, Color color) {
    int scale = size / 10;  // Base size 10, scale up
    if (scale < 1) scale = 1;

    int curX = x;
    while (*text) {
        char c = *text++;
        int idx = (c >= 32 && c <= 127) ? (c - 32) : 0;

        for (int i = 0; i < 5; i++) {
            uint8_t line = font5x7[idx][i];
            for (int s1 = 0; s1 < scale; s1++) {
                for (int j = 0; j < 7; j++) {
                    if (line & (1 << j)) {
                        for (int s2 = 0; s2 < scale; s2++) {
                            rl_draw_pixel(curX + i * scale + s1, y + j * scale + s2, color);
                        }
                    }
                }
            }
        }
        curX += 6 * scale;
    }
}

uint16_t *rl_get_framebuffer(void) { return fb; }
int rl_get_width(void) { return RL_CANVAS_WIDTH; }
int rl_get_height(void) { return RL_CANVAS_HEIGHT; }
